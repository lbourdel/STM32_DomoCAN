# Keil uVision project STM32_Domocan.uvprojx, settings and files
target NucleoF446xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Domo
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEBUG
  c include: .\Inc;.\System_Files
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Src
    ./Src/: can.c gpio.c interrupt.c main.c SysClock.c SysTick.c timer.c
  group Inc
    ./Inc/: can.h gpio.h interrupt.h main.h PinNames.h SysClock.h SysTick.h timer.h
  group System_Files
    ./System_Files/: stm32f446xx.h stm32f4xx_hal_gpio_ex.h
  group StartUp
    ./System_Files/: startup_stm32f446xx.s
  group DoxyGen
    ./: STM32_Domocan.doxy
software components: CMSIS:CORE 5.0.0, Compiler:I/O:STDOUT 1.1.0
